PACKAGECONFIG:append = " qt5 v4l2 libv4l2"
DEPENDS:append = " qtbase qtdeclarative qtbase-native qttools-native"